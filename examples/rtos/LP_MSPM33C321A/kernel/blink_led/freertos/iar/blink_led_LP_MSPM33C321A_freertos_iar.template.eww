<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/blink_led_LP_MSPM33C321A_freertos_iar.ewp</path>
    </project>
    <project>
        <path>$MSPM33_SDK_INSTALL_DIR$/kernel/freertos/builds/LP_MSPM33C321A/release/iar/freertos_builds_LP_MSPM33C321A_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>