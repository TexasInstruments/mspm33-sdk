<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/uart_internal_loopback_with_interrupt_spgss0_uc1_LP_MSPM33C321A_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>