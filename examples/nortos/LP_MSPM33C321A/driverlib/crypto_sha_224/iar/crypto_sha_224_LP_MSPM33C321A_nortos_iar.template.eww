<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/crypto_sha_224_LP_MSPM33C321A_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>