# IAR project uart_internal_loopback_standby_restore_LP_MSPM33C321A_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: uart_internal_loopback_standby_restore_LP_MSPM33C321A_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
