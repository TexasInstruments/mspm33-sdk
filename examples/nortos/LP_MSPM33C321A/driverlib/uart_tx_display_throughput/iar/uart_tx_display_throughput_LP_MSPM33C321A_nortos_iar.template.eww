<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/uart_tx_display_throughput_LP_MSPM33C321A_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>