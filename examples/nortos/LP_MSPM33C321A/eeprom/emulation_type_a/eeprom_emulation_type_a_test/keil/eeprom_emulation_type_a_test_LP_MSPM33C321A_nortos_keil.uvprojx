# Keil uVision project eeprom_emulation_type_a_test_LP_MSPM33C321A_nortos_keil.uvprojx, settings and files
target eeprom_emulation_type_a_test_LP_MSPM33C321A_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM33C321A Texas Instruments
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x00100000) XRAM(0x80000000,0x00008000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: eeprom_emulation_type_a_test_LP_MSPM33C321A_nortos_keil +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM33C321A__,__packed=__attribute__((packed))
  c include: ../../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../../source
  scatter file: ./mspm33c321a.sct
  link misc: ../../../../../../../source/ti/driverlib/lib/keil/m33/mspm33c321x/driverlib.a
  group Source
    ../: main.c ti_msp_dl_config.h ti_msp_dl_config.c
    ../ti/eeprom/emulation_type_a/: eeprom_emulation_type_a.c eeprom_emulation_type_a.h
    ../ti/eeprom/emulation_type_b/: eeprom_emulation_type_b.c eeprom_emulation_type_b.h
    ./: startup_mspm33c321x_uvision.s system_mspm33c321x.c
