# IAR project freertos_builds_LP_MSPM33C321A_release.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM33C321A TexasInstruments MSPM33C321A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 6
  ICCARM.IExtraOptions: -D__MSPM33C321A__; -Dewarm; -I$MSPM33_SDK_INSTALL_DIR$/kernel/freertos/Source/include; -I$MSPM33_SDK_INSTALL_DIR$/kernel/freertos/Source/portable/IAR/ARM_CM33_NTZ/non_secure; -I$MSPM33_SDK_INSTALL_DIR$/source/third_party/CMSIS/Core/Include; -I$MSPM33_SDK_INSTALL_DIR$/source; -I..; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $MSPM33_SDK_INSTALL_DIR$/kernel/freertos/Source/include; ..
  OBJCOPY.OOCOutputFile: freertos_builds_LP_MSPM33C321A_release.srec
  ILINK.IlinkOutputFile: freertos_builds_LP_MSPM33C321A_release.out
  ILINK.IlinkIcfFile: $MSPM33_SDK_INSTALL_DIR$\source\ti\devices\msp\m33\linker_files\iar\mspm33c321a.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group FreeRTOS kernel project/Header files
    ../: FreeRTOSConfig.h
  group FreeRTOS kernel project/Source files
    $MSPM33_SDK_INSTALL_DIR$/kernel/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    $MSPM33_SDK_INSTALL_DIR$/kernel/freertos/Source/portable/MemMang/: heap_4.c
    $MSPM33_SDK_INSTALL_DIR$/kernel/freertos/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s mpu_wrappers_v2_asm.S
    $MSPM33_SDK_INSTALL_DIR$/source/ti/devices/msp/m33/startup_system_files/iar/: startup_mspm33c321x_iar.c
    $MSPM33_SDK_INSTALL_DIR$/source/ti/devices/msp/m33/startup_system_files/: system_mspm33c321x.c
